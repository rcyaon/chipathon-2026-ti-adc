** sch_path: analog/top/top.sch
**.subckt top
V8 CLK 0 PULSE(0 3.3 0 50p 50p 1250n 2500n)
V3 VDD 0 3.3
V1 RST 0 PULSE(3.3 0 0 1n 1n 15n 100000n)
V6 VIN 0 0.2
V2 VRef 0 1.8
V9 CLK_N 0 PULSE(3.3 0 0 50p 50p 40n 80n)
x3 OUTN OUTP CLK_O 0 VDD VX net6 realcomp
x4 0 VDD CTRL2 CTRL1 CTRL0 CTRL3 net3 net4 net1 net2 CTRL5 CTRL7 CTRL4 CTRL6 net5 net7 net9 net8
+ inverter_block
x6 VDD VSAMPLE CLK VIN 0 transmission_gate
X1 VDD 0 CLK CLK_O CTRL0 CTRL1 CTRL2 CTRL3 CTRL4 CTRL5 CTRL6 CTRL7 DOUT0 DOUT1 DOUT2 DOUT3 DOUT4
+ DOUT5 DOUT6 DOUT7 OUTN OUTP RST sar_adc_logic
x2 VDD net1 net2 net3 VSAMPLE net4 0 VDD net5 net7 VRef net9 CLK net8 0 VDD CTRL0 VX CTRL1 CTRL2
+ VX_LSB CTRL3 0 CTRL4 CTRL5 CTRL6 CTRL7 caps2
V4 net6 0 0.9
**** begin user architecture code


.subckt sar_adc_logic VDD VSS clk_i clk_o dac_ctrl[0] dac_ctrl[1] dac_ctrl[2] dac_ctrl[3]
+  dac_ctrl[4] dac_ctrl[5] dac_ctrl[6] dac_ctrl[7] dout[0] dout[1] dout[2] dout[3]  dout[4] dout[5] dout[6]
+ dout[7] out_n out_p rst_n
XFILLER_22_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[203].delay_buf dly_stage[203].delay_buf/I dly_stage[204].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[132].delay_buf dly_stage[132].delay_buf/I dly_stage[133].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_18_203 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_8_88 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_24_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_20_Left_50 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[84].delay_buf dly_stage[84].delay_buf/I dly_stage[85].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_062_ wire25/Z _105_/Q _106_/Q _063_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_2
XFILLER_20_231 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[33].delay_buf dly_stage[33].delay_buf/I dly_stage[34].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_045_ _087_/Q _057_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[253].delay_buf dly_stage[253].delay_buf/I dly_stage[254].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xhold30 _083_/Q _097_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[182].delay_buf dly_stage[182].delay_buf/I dly_stage[183].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_150 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[202].delay_buf dly_stage[202].delay_buf/I dly_stage[203].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_76 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_25_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput7 _085_/Q dac_ctrl[4] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[131].delay_buf dly_stage[131].delay_buf/I dly_stage[132].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[83].delay_buf dly_stage[83].delay_buf/I dly_stage[84].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_18_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[32].delay_buf dly_stage[32].delay_buf/I dly_stage[33].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_8_89 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_EDGE_ROW_12_Right_12 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_0_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_2_155 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[252].delay_buf dly_stage[252].delay_buf/I dly_stage[253].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_061_ _061_/A1 _104_/Q _061_/B _085_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_18_43 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_5_79 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[181].delay_buf dly_stage[181].delay_buf/I dly_stage[182].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_044_ _088_/Q _055_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[201].delay_buf dly_stage[201].delay_buf/I dly_stage[202].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_88 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xhold31 _088_/Q _092_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[130].delay_buf dly_stage[130].delay_buf/I dly_stage[131].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_1__f_valid_clk_regs clkbuf_0_valid_clk_regs/Z _103_/CLK VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_19_162 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[149].delay_buf dly_stage[149].delay_buf/I dly_stage[150].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_6_Right_6 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[82].delay_buf dly_stage[82].delay_buf/I dly_stage[83].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xoutput10 _090_/Q dac_ctrl[7] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xoutput8 _084_/Q dac_ctrl[5] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_13_124 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_13_146 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[31].delay_buf dly_stage[31].delay_buf/I dly_stage[32].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[251].delay_buf dly_stage[251].delay_buf/I dly_stage[252].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_208 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[180].delay_buf dly_stage[180].delay_buf/I dly_stage[181].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[200].delay_buf dly_stage[200].delay_buf/I dly_stage[201].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[199].delay_buf dly_stage[199].delay_buf/I dly_stage[200].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_060_ wire25/Z _104_/Q _105_/Q _061_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_29_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[219].delay_buf dly_stage[219].delay_buf/I dly_stage[220].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_8_Left_38 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
X_043_ _089_/Q _053_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[148].delay_buf dly_stage[148].delay_buf/I dly_stage[149].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_3_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[81].delay_buf dly_stage[81].delay_buf/I dly_stage[82].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xhold32 _087_/Q _093_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_16_111 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_144 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xoutput11 _091_/Q dout[0] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xoutput9 _083_/Q dac_ctrl[6] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[30].delay_buf dly_stage[30].delay_buf/I dly_stage[31].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_16_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_103 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[49].delay_buf dly_stage[49].delay_buf/I dly_stage[50].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_169 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_15_109 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[250].delay_buf dly_stage[250].delay_buf/I dly_stage[251].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[198].delay_buf dly_stage[198].delay_buf/I dly_stage[199].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[218].delay_buf dly_stage[218].delay_buf/I dly_stage[219].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[147].delay_buf dly_stage[147].delay_buf/I dly_stage[148].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_24_Left_54 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_18_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[80].delay_buf dly_stage[80].delay_buf/I dly_stage[81].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_7_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[99].delay_buf dly_stage[99].delay_buf/I dly_stage[99].delay_buf/Z  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_042_ _107_/Q _108_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_6_26 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xhold33 _089_/Q _091_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_19_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[48].delay_buf dly_stage[48].delay_buf/I dly_stage[49].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_57 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_11_Left_41 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xoutput12 _092_/Q dout[1] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XTAP_TAPCELL_ROW_18_118 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_26_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[197].delay_buf dly_stage[197].delay_buf/I dly_stage[198].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_126 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_13_137 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[217].delay_buf dly_stage[217].delay_buf/I dly_stage[218].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_20_124 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[146].delay_buf dly_stage[146].delay_buf/I dly_stage[147].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_23_68 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_26 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_0_60 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[98].delay_buf dly_stage[98].delay_buf/I dly_stage[99].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_9_91 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_7_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[47].delay_buf dly_stage[47].delay_buf/I dly_stage[48].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkload0 _103_/CLK clkload0/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_2
XFILLER_1_60 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xhold34 _090_/Q _098_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_19_154 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[196].delay_buf dly_stage[196].delay_buf/I dly_stage[197].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xcomp_trigger_driver comp_trigger_driver/I clk_o VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_16
XFILLER_25_146 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput13 _093_/Q dout[2] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XPHY_EDGE_ROW_19_Right_19 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_18_119 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[216].delay_buf dly_stage[216].delay_buf/I dly_stage[217].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[145].delay_buf dly_stage[145].delay_buf/I dly_stage[146].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_23_133 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_12_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_20_125 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[97].delay_buf dly_stage[97].delay_buf/I dly_stage[98].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_valid_clk valid_clk_xor/Z clkbuf_0_valid_clk/Z VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_23_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[46].delay_buf dly_stage[46].delay_buf/I dly_stage[47].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_29 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_0_61 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_9_92 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_1_50 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_6_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[195].delay_buf dly_stage[195].delay_buf/I dly_stage[196].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[215].delay_buf dly_stage[215].delay_buf/I dly_stage[216].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_6_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_6_82 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[144].delay_buf dly_stage[144].delay_buf/I dly_stage[145].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_103 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_191 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_26_142 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput14 _094_/Q dout[3] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xclkbuf_1_0__f_eoc clkbuf_0_eoc/Z comp_trigger_nor/A2 VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xdly_stage[96].delay_buf dly_stage[96].delay_buf/I dly_stage[97].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_23_134 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_10_109 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_20_126 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[45].delay_buf dly_stage[45].delay_buf/I dly_stage[46].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[194].delay_buf dly_stage[194].delay_buf/I dly_stage[195].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_204 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_0_62 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_9_93 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_18_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[214].delay_buf dly_stage[214].delay_buf/I dly_stage[215].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_28_Left_58 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[143].delay_buf dly_stage[143].delay_buf/I dly_stage[144].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_099_ _100_/Q _099_/RN _103_/CLK _099_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_28_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_19_178 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_28_167 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_28_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_29_151 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_107__26 _107_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__tiel
XFILLER_25_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_6_83 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[95].delay_buf dly_stage[95].delay_buf/I dly_stage[96].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_170 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_1_Right_1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_26_143 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput15 _095_/Q dout[4] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_22_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_7_50 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_15_Left_45 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[44].delay_buf dly_stage[44].delay_buf/I dly_stage[45].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XTAP_TAPCELL_ROW_23_135 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_29_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_3_73 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_26_210 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[193].delay_buf dly_stage[193].delay_buf/I dly_stage[194].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_4_95 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[213].delay_buf dly_stage[213].delay_buf/I dly_stage[214].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[142].delay_buf dly_stage[142].delay_buf/I dly_stage[143].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_0_63 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_3_Left_33 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[94].delay_buf dly_stage[94].delay_buf/I dly_stage[95].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_098_ _098_/D _050_/I _098_/CLK _098_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_10_94 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_10_94 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_29_152 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_6_84 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[43].delay_buf dly_stage[43].delay_buf/I dly_stage[44].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_138 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_26_144 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput16 _096_/Q dout[5] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_15_182 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_21_152 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_7_62 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_15_Right_15 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[192].delay_buf dly_stage[192].delay_buf/I dly_stage[193].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_3_74 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[212].delay_buf dly_stage[212].delay_buf/I dly_stage[213].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[141].delay_buf dly_stage[141].delay_buf/I dly_stage[142].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_4_30 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_0_64 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[93].delay_buf dly_stage[93].delay_buf/I dly_stage[94].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[109].delay_buf dly_stage[109].delay_buf/I dly_stage[110].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[42].delay_buf dly_stage[42].delay_buf/I dly_stage[43].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_097_ _097_/D _050_/I _098_/CLK _097_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XTAP_TAPCELL_ROW_10_95 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xhold27 _086_/Q _094_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XTAP_TAPCELL_ROW_29_153 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_15_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xoutput17 _097_/Q dout[6] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[191].delay_buf dly_stage[191].delay_buf/I dly_stage[192].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_50 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[211].delay_buf dly_stage[211].delay_buf/I dly_stage[212].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[140].delay_buf dly_stage[140].delay_buf/I dly_stage[141].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_120 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[159].delay_buf dly_stage[159].delay_buf/I dly_stage[160].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_197 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_3_75 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_26_201 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_138 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[92].delay_buf dly_stage[92].delay_buf/I dly_stage[93].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_171 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[108].delay_buf dly_stage[108].delay_buf/I dly_stage[109].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_0_65 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[41].delay_buf dly_stage[41].delay_buf/I dly_stage[42].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_11_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_10_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[190].delay_buf dly_stage[190].delay_buf/I dly_stage[191].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_096_ _096_/D _050_/I _098_/CLK _096_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XTAP_TAPCELL_ROW_10_96 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xhold28 _084_/Q _096_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
XFILLER_10_96 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_19_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_29_154 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[210].delay_buf dly_stage[210].delay_buf/I dly_stage[211].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_18_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xoutput18 _098_/Q dout[7] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[229].delay_buf dly_stage[229].delay_buf/I dly_stage[230].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_079_ _079_/A1 _082_/A2 _088_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_24_162 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[158].delay_buf dly_stage[158].delay_buf/I dly_stage[159].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_110 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_5_Right_5 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[91].delay_buf dly_stage[91].delay_buf/I dly_stage[92].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[107].delay_buf dly_stage[107].delay_buf/I dly_stage[108].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_19_Left_49 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_26_235 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[40].delay_buf dly_stage[40].delay_buf/I dly_stage[41].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_202 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_27_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[59].delay_buf dly_stage[59].delay_buf/I dly_stage[60].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_4_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_9_220 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_0_66 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_6_201 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[228].delay_buf dly_stage[228].delay_buf/I dly_stage[229].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_095_ _095_/D _050_/I _095_/CLK _095_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
Xhold29 _085_/Q _095_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyc_1
Xdly_stage[157].delay_buf dly_stage[157].delay_buf/I dly_stage[158].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_7_Left_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_29_155 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[90].delay_buf dly_stage[90].delay_buf/I dly_stage[91].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_078_ _079_/A1 _081_/A2 _087_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_24_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_24_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[106].delay_buf dly_stage[106].delay_buf/I dly_stage[107].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_196 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_7_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_21_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_8_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_11_Right_11 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_14_106 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[58].delay_buf dly_stage[58].delay_buf/I dly_stage[59].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_4_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[227].delay_buf dly_stage[227].delay_buf/I dly_stage[228].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_8_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[156].delay_buf dly_stage[156].delay_buf/I dly_stage[157].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_094_ _094_/D _050_/I _098_/CLK _094_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XPHY_EDGE_ROW_23_Left_53 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[105].delay_buf dly_stage[105].delay_buf/I dly_stage[106].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_27_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_205 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_3_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_29_156 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_077_ _082_/A1 _080_/A2 _086_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[57].delay_buf dly_stage[57].delay_buf/I dly_stage[58].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_7_88 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_17_115 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_21_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_10_Left_40 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_12_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_14_107 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[226].delay_buf dly_stage[226].delay_buf/I dly_stage[227].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_23_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_163 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_4_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_4_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[155].delay_buf dly_stage[155].delay_buf/I dly_stage[156].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_13_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[104].delay_buf dly_stage[104].delay_buf/I dly_stage[105].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_232 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_6_225 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_093_ _093_/D _050_/I _095_/CLK _093_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_19_118 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_28_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[56].delay_buf dly_stage[56].delay_buf/I dly_stage[57].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xinput1 out_n input1/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XTAP_TAPCELL_ROW_29_157 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xclkbuf_0_valid_clk_regs clkbuf_regs_0_valid_clk/Z clkbuf_0_valid_clk_regs/Z VDD VDD  VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_076_ _082_/A1 _080_/A2 _085_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_24_154 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_17_116 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_21_135 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[225].delay_buf dly_stage[225].delay_buf/I dly_stage[226].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_059_ _059_/A1 _103_/Q _059_/B _086_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_12_113 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_16_32 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_14_108 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_22_130 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_190 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_9_Right_9 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[154].delay_buf dly_stage[154].delay_buf/I dly_stage[155].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[103].delay_buf dly_stage[103].delay_buf/I dly_stage[104].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_9_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[55].delay_buf dly_stage[55].delay_buf/I dly_stage[56].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_eoc_regs clkbuf_0_eoc_regs/I clkbuf_0_eoc_regs/Z VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_092_ _092_/D _050_/I _095_/CLK _092_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_3_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xinput2 out_p wire25/I VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_1
X_075_ _082_/A1 _080_/A2 _084_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_18_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[224].delay_buf dly_stage[224].delay_buf/I dly_stage[225].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_122 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_24_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_17_117 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xmax_cap20 _080_/A2 _082_/A2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xdly_stage[153].delay_buf dly_stage[153].delay_buf/I dly_stage[154].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_058_ wire25/Z _103_/Q _104_/Q _059_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_29_203 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_22_131 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_20_191 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[102].delay_buf dly_stage[102].delay_buf/I dly_stage[103].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_23_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[54].delay_buf dly_stage[54].delay_buf/I dly_stage[55].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_9_202 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_1_48 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_6_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_6_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[223].delay_buf dly_stage[223].delay_buf/I dly_stage[224].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_091_ _091_/D _050_/I _095_/CLK _091_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XPHY_EDGE_ROW_18_Right_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_10_24 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[152].delay_buf dly_stage[152].delay_buf/I dly_stage[153].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_074_ _108_/Q _080_/A2 _083_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XPHY_EDGE_ROW_27_Left_57 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_21_78 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_24_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[101].delay_buf dly_stage[101].delay_buf/I dly_stage[102].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_178 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_7_14 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_7_58 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_25_140 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xmax_cap21 _108_/Q _081_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xclkbuf_1_0__f_valid_clk clkbuf_0_valid_clk/Z comp_trigger_nor/A1 VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
X_057_ _057_/A1 _102_/Q _057_/B _087_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_16_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_21_148 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_115 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_0_Right_0 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_22_132 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[53].delay_buf dly_stage[53].delay_buf/I dly_stage[54].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_14_Left_44 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_25_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_66 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_4_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[222].delay_buf dly_stage[222].delay_buf/I dly_stage[223].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[151].delay_buf dly_stage[151].delay_buf/I dly_stage[152].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_6_217 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_090_ _090_/D _081_/ZN _107_/CLK _090_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffsnq_1
XFILLER_3_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[100].delay_buf dly_stage[99].delay_buf/Z dly_stage[101].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_2_Left_32 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[119].delay_buf dly_stage[119].delay_buf/I dly_stage[120].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_073_ _081_/A1 _081_/A2 _073_/ZN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_21_46 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_135 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_25_141 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[52].delay_buf dly_stage[52].delay_buf/I dly_stage[53].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xmax_cap22 _079_/A1 _066_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
X_056_ wire25/I _102_/Q _103_/Q _057_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_21_127 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_16_24 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_11_160 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_14_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_26_208 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_108_ _108_/D _050_/I clk_i _108_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffnrnq_1
Xdly_stage[221].delay_buf dly_stage[221].delay_buf/I dly_stage[222].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_200 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[169].delay_buf dly_stage[169].delay_buf/I dly_stage[170].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[150].delay_buf dly_stage[150].delay_buf/I dly_stage[151].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[118].delay_buf dly_stage[118].delay_buf/I dly_stage[119].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_166 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[51].delay_buf dly_stage[51].delay_buf/I dly_stage[52].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_18_100 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_18_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_28_150 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_072_ _081_/A1 _081_/A2 _106_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_15_158 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xmax_cap23 _082_/A1 _079_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xdly_stage[19].delay_buf dly_stage[19].delay_buf/I dly_stage[20].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_055_ _055_/A1 _101_/Q _055_/B _088_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_14_191 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_21_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_20_183 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_29_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[220].delay_buf dly_stage[220].delay_buf/I dly_stage[221].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[239].delay_buf dly_stage[239].delay_buf/I dly_stage[240].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_107_ _107_/D _073_/ZN _107_/CLK _107_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffsnq_2
Xdly_stage[168].delay_buf dly_stage[168].delay_buf/I dly_stage[169].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[117].delay_buf dly_stage[117].delay_buf/I dly_stage[118].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_9_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[50].delay_buf dly_stage[50].delay_buf/I dly_stage[51].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[69].delay_buf dly_stage[69].delay_buf/I dly_stage[70].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_18_167 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_27_112 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_211 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_4_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_14_Right_14 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[18].delay_buf dly_stage[18].delay_buf/I dly_stage[19].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_071_ _081_/A1 _081_/A2 _105_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_18_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xmax_cap24 _108_/Q _082_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xdly_stage[238].delay_buf dly_stage[238].delay_buf/I dly_stage[239].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_118 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[167].delay_buf dly_stage[167].delay_buf/I dly_stage[168].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_054_ wire25/I _101_/Q _102_/Q _055_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
X_106_ _107_/Q _106_/RN _107_/CLK _106_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
XPHY_EDGE_ROW_4_Right_4 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[116].delay_buf dly_stage[116].delay_buf/I dly_stage[117].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_4_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_18_Left_48 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[68].delay_buf dly_stage[68].delay_buf/I dly_stage[69].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_172 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_24_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
Xdly_stage[17].delay_buf dly_stage[17].delay_buf/I dly_stage[18].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_28 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[237].delay_buf dly_stage[237].delay_buf/I dly_stage[238].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_070_ _081_/A1 _081_/A2 _104_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[166].delay_buf dly_stage[166].delay_buf/I dly_stage[167].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_190 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_21_38 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_6_Left_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_15_127 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_16_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[115].delay_buf dly_stage[115].delay_buf/I dly_stage[116].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_053_ _053_/A1 _100_/Q _053_/B _089_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_11_152 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_11_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_13_103 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_105_ _106_/Q _105_/RN _107_/CLK _105_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
Xdly_stage[67].delay_buf dly_stage[67].delay_buf/I dly_stage[68].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_3_192 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_22_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[16].delay_buf dly_stage[16].delay_buf/I dly_stage[17].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[236].delay_buf dly_stage[236].delay_buf/I dly_stage[237].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[165].delay_buf dly_stage[165].delay_buf/I dly_stage[166].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_27_158 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_2_235 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[114].delay_buf dly_stage[114].delay_buf/I dly_stage[115].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_2_30 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_22_Left_52 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_15_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_052_ wire25/Z _100_/Q _101_/Q _053_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__aoi21_1
XFILLER_14_150 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_16_112 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[66].delay_buf dly_stage[66].delay_buf/I dly_stage[67].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_13_104 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_11_131 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_19_231 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_22_71 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[15].delay_buf dly_stage[15].delay_buf/I dly_stage[16].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_104_ _105_/Q _104_/RN _107_/CLK _104_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
XFILLER_25_234 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xclkbuf_regs_1_eoc_clk _099_/Q clkbuf_0_eoc_regs/I VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
Xdly_stage[235].delay_buf dly_stage[235].delay_buf/I dly_stage[236].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[164].delay_buf dly_stage[164].delay_buf/I dly_stage[165].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_63 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_10_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[113].delay_buf dly_stage[113].delay_buf/I dly_stage[114].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_1__f_eoc_regs clkbuf_0_eoc_regs/Z _095_/CLK VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_27_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_27_148 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_18_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[65].delay_buf dly_stage[65].delay_buf/I dly_stage[66].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_24_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_10_Right_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_19_121 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_2_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
X_051_ _090_/Q wire25/I _107_/Q _090_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__mux2_2
XTAP_TAPCELL_ROW_16_113 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_7_85 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[14].delay_buf dly_stage[14].delay_buf/I dly_stage[15].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_13_105 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[234].delay_buf dly_stage[234].delay_buf/I dly_stage[235].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_103_ _104_/Q _103_/RN _103_/CLK _103_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
Xdly_stage[9].delay_buf dly_stage[9].delay_buf/I dly_stage[9].delay_buf/Z VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[163].delay_buf dly_stage[163].delay_buf/I dly_stage[164].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_22_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_8_Right_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xclkbuf_1_0__f_eoc_regs clkbuf_0_eoc_regs/Z _098_/CLK VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_13_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xvalid_clk_xor wire25/Z input1/Z valid_clk_xor/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__xor2_4
Xdly_stage[112].delay_buf dly_stage[112].delay_buf/I dly_stage[113].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_164 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_5_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[64].delay_buf dly_stage[64].delay_buf/I dly_stage[65].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_27_138 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_25_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[13].delay_buf dly_stage[13].delay_buf/I dly_stage[14].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_171 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_17_182 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_19_122 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_23_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_050_ _050_/I _080_/A2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__inv_1
XFILLER_14_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_16_114 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_7_86 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[8].delay_buf dly_stage[8].delay_buf/I dly_stage[9].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[233].delay_buf dly_stage[233].delay_buf/I dly_stage[234].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_155 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_28_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[162].delay_buf dly_stage[162].delay_buf/I dly_stage[163].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_133 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_102_ _103_/Q _102_/RN _107_/CLK _102_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
Xdly_stage[111].delay_buf dly_stage[111].delay_buf/I dly_stage[112].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_4_76 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[63].delay_buf dly_stage[63].delay_buf/I dly_stage[64].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xcomp_trigger_nor comp_trigger_nor/A1 comp_trigger_nor/A2 _066_/A1 comp_trigger_nor/ZN  VDD VDD VSS
+ VSS gf180mcu_fd_sc_mcu7t5v0__nor3_4
XFILLER_0_110 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[12].delay_buf dly_stage[12].delay_buf/I dly_stage[13].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_180 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_2_227 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[232].delay_buf dly_stage[232].delay_buf/I dly_stage[233].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_150 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_17_194 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_24_109 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_183 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_2_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_19_123 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[7].delay_buf dly_stage[7].delay_buf/I dly_stage[8].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[161].delay_buf dly_stage[161].delay_buf/I dly_stage[162].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_153 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_TAPCELL_ROW_11_97 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XPHY_EDGE_ROW_26_Left_56 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_7_87 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[110].delay_buf dly_stage[110].delay_buf/I dly_stage[111].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_167 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[129].delay_buf dly_stage[129].delay_buf/I dly_stage[130].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_101_ _102_/Q _101_/RN _103_/CLK _101_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
XFILLER_19_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_8_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[62].delay_buf dly_stage[62].delay_buf/I dly_stage[63].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_6 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_3_196 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_4_77 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_13_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XPHY_EDGE_ROW_13_Left_43 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[11].delay_buf dly_stage[11].delay_buf/I dly_stage[12].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_5_214 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[6].delay_buf dly_stage[6].delay_buf/I dly_stage[7].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[231].delay_buf dly_stage[231].delay_buf/I dly_stage[232].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_1_67 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[160].delay_buf dly_stage[160].delay_buf/I dly_stage[161].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_2_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[179].delay_buf dly_stage[179].delay_buf/I dly_stage[180].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_173 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_11_98 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xmax_cap19 _082_/A2 _081_/A2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
Xdly_stage[128].delay_buf dly_stage[128].delay_buf/I dly_stage[129].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_1_0__f_valid_clk_regs clkbuf_0_valid_clk_regs/Z _107_/CLK VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XPHY_EDGE_ROW_1_Left_31 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[61].delay_buf dly_stage[61].delay_buf/I dly_stage[62].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_100_ _101_/Q _100_/RN _103_/CLK _100_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_0_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_25_238 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[10].delay_buf dly_stage[9].delay_buf/Z dly_stage[11].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_4_78 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[29].delay_buf dly_stage[29].delay_buf/I dly_stage[30].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[230].delay_buf dly_stage[230].delay_buf/I dly_stage[231].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_17_Right_17 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[5].delay_buf dly_stage[5].delay_buf/I dly_stage[6].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[249].delay_buf dly_stage[249].delay_buf/I dly_stage[250].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_67 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_5_78 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[178].delay_buf dly_stage[178].delay_buf/I dly_stage[179].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_160 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_1_68 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[127].delay_buf dly_stage[127].delay_buf/I dly_stage[128].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_1_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[60].delay_buf dly_stage[60].delay_buf/I dly_stage[61].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_133 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_11_99 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XTAP_TAPCELL_ROW_25_139 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[79].delay_buf dly_stage[79].delay_buf/I dly_stage[80].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_166 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_14_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_14_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_20_103 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[28].delay_buf dly_stage[28].delay_buf/I dly_stage[29].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_206 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[4].delay_buf dly_stage[4].delay_buf/I dly_stage[5].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[248].delay_buf dly_stage[248].delay_buf/I dly_stage[249].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_12_8 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_3_176 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_3_198 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[177].delay_buf dly_stage[177].delay_buf/I dly_stage[178].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_213 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[126].delay_buf dly_stage[126].delay_buf/I dly_stage[127].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_14_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_29_172 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_1_69 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[78].delay_buf dly_stage[78].delay_buf/I dly_stage[79].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_28_148 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_17_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_17_175 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[27].delay_buf dly_stage[27].delay_buf/I dly_stage[28].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[3].delay_buf dly_stage[3].delay_buf/I dly_stage[4].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[247].delay_buf dly_stage[247].delay_buf/I dly_stage[248].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_148 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[176].delay_buf dly_stage[176].delay_buf/I dly_stage[177].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_25_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_089_ _089_/D _089_/RN _103_/CLK _089_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
Xdly_stage[125].delay_buf dly_stage[125].delay_buf/I dly_stage[126].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_3_Right_3 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_5_69 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_10_6 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_17_Left_47 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[77].delay_buf dly_stage[77].delay_buf/I dly_stage[78].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[26].delay_buf dly_stage[26].delay_buf/I dly_stage[27].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_28_149 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xrst_root rst_n _050_/I VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_8
Xdly_stage[2].delay_buf dly_stage[2].delay_buf/I dly_stage[3].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[246].delay_buf dly_stage[246].delay_buf/I dly_stage[247].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_146 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_14_113 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[175].delay_buf dly_stage[175].delay_buf/I dly_stage[176].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_22_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XPHY_EDGE_ROW_5_Left_35 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[124].delay_buf dly_stage[124].delay_buf/I dly_stage[125].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_160 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_14 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_12_100 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
X_088_ _088_/D _088_/RN _103_/CLK _088_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XTAP_TAPCELL_ROW_8_90 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[76].delay_buf dly_stage[76].delay_buf/I dly_stage[77].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_70 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_12_211 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_8_237 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_13_Right_13 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XTAP_TAPCELL_ROW_5_80 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[25].delay_buf dly_stage[25].delay_buf/I dly_stage[26].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_207 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[245].delay_buf dly_stage[245].delay_buf/I dly_stage[246].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[1].delay_buf dly_stage[1].delay_buf/I dly_stage[2].delay_buf/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_144 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[174].delay_buf dly_stage[174].delay_buf/I dly_stage[175].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_122 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_26_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_9_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XTAP_TAPCELL_ROW_2_70 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[123].delay_buf dly_stage[123].delay_buf/I dly_stage[124].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_191 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_20_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XPHY_EDGE_ROW_21_Left_51 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_19_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_8_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_12_101 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[75].delay_buf dly_stage[75].delay_buf/I dly_stage[76].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_087_ _087_/D _087_/RN _103_/CLK _087_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_24_220 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[24].delay_buf dly_stage[24].delay_buf/I dly_stage[25].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_24_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_28_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[244].delay_buf dly_stage[244].delay_buf/I dly_stage[245].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[0].delay_buf comp_trigger_nor/ZN dly_stage[1].delay_buf/I VDD VDD VSS  VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_5_81 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[173].delay_buf dly_stage[173].delay_buf/I dly_stage[174].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_120 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[122].delay_buf dly_stage[122].delay_buf/I dly_stage[123].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_25_68 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_26_101 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_26_134 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_23_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_2_71 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_14_115 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_23_137 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[74].delay_buf dly_stage[74].delay_buf/I dly_stage[75].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XTAP_TAPCELL_ROW_15_110 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_19_218 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_12_102 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[23].delay_buf dly_stage[23].delay_buf/I dly_stage[24].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_086_ _086_/D _086_/RN _103_/CLK _086_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
Xclkbuf_regs_0_valid_clk valid_clk_xor/Z clkbuf_regs_0_valid_clk/Z VDD VDD VSS VSS
+  gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_24_210 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[243].delay_buf dly_stage[243].delay_buf/I dly_stage[244].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[172].delay_buf dly_stage[172].delay_buf/I dly_stage[173].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_069_ _079_/A1 _082_/A2 _103_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_21_202 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_12_235 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_8_217 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_14_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XPHY_EDGE_ROW_7_Right_7 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[121].delay_buf dly_stage[121].delay_buf/I dly_stage[122].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_5_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_4_231 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_1_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_25_36 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_26_157 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
Xdly_stage[73].delay_buf dly_stage[73].delay_buf/I dly_stage[74].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xclkbuf_0_eoc _099_/Q clkbuf_0_eoc/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkbuf_16
XFILLER_17_157 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_2_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XTAP_TAPCELL_ROW_2_72 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[22].delay_buf dly_stage[22].delay_buf/I dly_stage[23].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_15_111 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[242].delay_buf dly_stage[242].delay_buf/I dly_stage[243].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[171].delay_buf dly_stage[171].delay_buf/I dly_stage[172].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_085_ _085_/D _085_/RN _107_/CLK _085_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XPHY_EDGE_ROW_9_Left_39 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[120].delay_buf dly_stage[120].delay_buf/I dly_stage[121].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_068_ _081_/A1 _081_/A2 _102_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_0_62 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_21_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[139].delay_buf dly_stage[139].delay_buf/I dly_stage[140].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[72].delay_buf dly_stage[72].delay_buf/I dly_stage[73].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_144 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_29_199 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[21].delay_buf dly_stage[21].delay_buf/I dly_stage[22].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_23_117 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_23_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_18_120 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[241].delay_buf dly_stage[241].delay_buf/I dly_stage[242].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
Xdly_stage[170].delay_buf dly_stage[170].delay_buf/I dly_stage[171].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[189].delay_buf dly_stage[189].delay_buf/I dly_stage[190].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_19_209 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_220 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_29_Right_29 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[209].delay_buf dly_stage[209].delay_buf/I dly_stage[210].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_197 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_25_Left_55 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[138].delay_buf dly_stage[138].delay_buf/I dly_stage[139].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_084_ _084_/D _084_/RN _107_/CLK _084_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_1
XFILLER_15_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[71].delay_buf dly_stage[71].delay_buf/I dly_stage[72].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_52 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_2_171 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
X_067_ _079_/A1 _082_/A2 _101_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_28_37 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_64
XFILLER_22_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[20].delay_buf dly_stage[20].delay_buf/I dly_stage[21].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_12_Left_42 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[39].delay_buf dly_stage[39].delay_buf/I dly_stage[40].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_71 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[240].delay_buf dly_stage[240].delay_buf/I dly_stage[241].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_26_115 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_6_73 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[259].delay_buf dly_stage[259].delay_buf/I comp_trigger_driver/I VDD  VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_137 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_1_236 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_25_192 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[188].delay_buf dly_stage[188].delay_buf/I dly_stage[189].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_170 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[208].delay_buf dly_stage[208].delay_buf/I dly_stage[209].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_13_195 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[137].delay_buf dly_stage[137].delay_buf/I dly_stage[138].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_21_127 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xwire25 wire25/I wire25/Z VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__buf_2
XFILLER_27_232 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_0_Left_30 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[70].delay_buf dly_stage[70].delay_buf/I dly_stage[71].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_083_ _083_/D _083_/RN _107_/CLK _083_/Q VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dffrnq_2
XFILLER_5_180 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[89].delay_buf dly_stage[89].delay_buf/I dly_stage[90].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_21_216 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[38].delay_buf dly_stage[38].delay_buf/I dly_stage[39].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_066_ _066_/A1 _082_/A2 _100_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XFILLER_12_227 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_049_ _083_/Q _065_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_14_18 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_15_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[258].delay_buf dly_stage[258].delay_buf/I dly_stage[259].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_29_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_29_70 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[187].delay_buf dly_stage[187].delay_buf/I dly_stage[188].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[207].delay_buf dly_stage[207].delay_buf/I dly_stage[208].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[136].delay_buf dly_stage[136].delay_buf/I dly_stage[137].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_61 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_16_160 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xoutput3 _089_/Q dac_ctrl[0] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_22_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_22_185 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XTAP_TAPCELL_ROW_24_136 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[88].delay_buf dly_stage[88].delay_buf/I dly_stage[89].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_21_128 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_10_177 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_082_ _082_/A1 _082_/A2 _099_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[37].delay_buf dly_stage[37].delay_buf/I dly_stage[38].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_214 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_0_10 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_23_72 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
Xdly_stage[257].delay_buf dly_stage[257].delay_buf/I dly_stage[258].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_065_ _065_/A1 _106_/Q _065_/B _108_/D _083_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai211_2
XFILLER_12_239 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[186].delay_buf dly_stage[186].delay_buf/I dly_stage[187].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[206].delay_buf dly_stage[206].delay_buf/I dly_stage[207].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_048_ _084_/Q _063_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_20_84 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[135].delay_buf dly_stage[135].delay_buf/I dly_stage[136].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_17_139 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_27_145 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[87].delay_buf dly_stage[87].delay_buf/I dly_stage[88].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xoutput4 _088_/Q dac_ctrl[1] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XTAP_TAPCELL_ROW_24_137 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_13_142 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_13_153 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XFILLER_13_197 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[36].delay_buf dly_stage[36].delay_buf/I dly_stage[37].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XTAP_TAPCELL_ROW_21_129 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
XFILLER_10_189 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_27_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_081_ _081_/A1 _081_/A2 _081_/ZN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
XPHY_EDGE_ROW_16_Right_16 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[256].delay_buf dly_stage[256].delay_buf/I dly_stage[257].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[185].delay_buf dly_stage[185].delay_buf/I dly_stage[186].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_0_33 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_15_204 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XPHY_EDGE_ROW_29_Left_59 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[205].delay_buf dly_stage[205].delay_buf/I dly_stage[206].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
X_064_ wire25/Z _106_/Q _065_/B VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nand2_2
XFILLER_0_66 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_0_99 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[134].delay_buf dly_stage[134].delay_buf/I dly_stage[135].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_11_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
X_047_ _085_/Q _061_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
XFILLER_29_104 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_16
XPHY_EDGE_ROW_2_Right_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
Xdly_stage[86].delay_buf dly_stage[86].delay_buf/I dly_stage[87].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_20_96 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_1_228 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_20_2 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_32
XFILLER_26_107 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XPHY_EDGE_ROW_16_Left_46 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
XFILLER_17_129 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_25_184 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_27_146 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput5 _087_/Q dac_ctrl[2] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
Xdly_stage[35].delay_buf dly_stage[35].delay_buf/I dly_stage[36].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_16_195 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
XFILLER_22_187 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XTAP_TAPCELL_ROW_24_138 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xdly_stage[255].delay_buf dly_stage[255].delay_buf/I dly_stage[256].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_3_66 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_4
Xdly_stage[184].delay_buf dly_stage[184].delay_buf/I dly_stage[185].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_10_168 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_27_202 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XFILLER_27_224 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
X_080_ _082_/A1 _080_/A2 _089_/RN VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__nor2_1
Xdly_stage[204].delay_buf dly_stage[204].delay_buf/I dly_stage[205].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[133].delay_buf dly_stage[133].delay_buf/I dly_stage[134].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XPHY_EDGE_ROW_4_Left_34 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__endcap
X_063_ _063_/A1 _105_/Q _063_/B _084_/D VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__oai21_1
XFILLER_0_56 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
XFILLER_18_41 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_2
Xdly_stage[85].delay_buf dly_stage[85].delay_buf/I dly_stage[86].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_7_212 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
X_046_ _086_/Q _059_/A1 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__clkinv_1
Xdly_stage[34].delay_buf dly_stage[34].delay_buf/I dly_stage[35].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
Xdly_stage[254].delay_buf dly_stage[254].delay_buf/I dly_stage[255].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
XFILLER_15_20 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_25_130 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fillcap_8
XTAP_TAPCELL_ROW_27_147 VDD VSS gf180mcu_fd_sc_mcu7t5v0__filltie
Xoutput6 _086_/Q dac_ctrl[3] VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__dlyd_1
XFILLER_0_240 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
XFILLER_16_174 VDD VDD VSS VSS gf180mcu_fd_sc_mcu7t5v0__fill_1
Xdly_stage[183].delay_buf dly_stage[183].delay_buf/I dly_stage[184].delay_buf/I  VDD VDD VSS VSS
+ gf180mcu_fd_sc_mcu7t5v0__buf_1
.ends



.include $::180MCU_MODELS/design.ngspice
.include $PDK_ROOT/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/smbb000149.ngspice typical
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib /foss/pdks/gf180mcuD/libs.tech/ngspice/sm141064.ngspice mimcap_typical



.tran 10n 1000n uic
.ic v(VX)=1.65 v(VX_LSB)=1.65

.control
run
wrdata trans_gate.txt v(vin) v(vsample) v(clk)
wrdata comparator.txt v(clk_o) v(outp) v(outn) v(clk)
wrdata logic.txt v(ctrl0) v(ctrl1) v(ctrl2) v(ctrl3) v(ctrl4) v(ctrl5) v(ctrl6) v(ctrl7) v(dout0)
+ v(dout1) v(dout2) v(dout3) v(dout4) v(dout5) v(dout6) v(dout7) v(clk)
wrdata cdac.txt v(vref) v(vx) v(vx_lsb) v(vsample)
.endc


**** end user architecture code
**.ends
.end
